# Keil uVision project EMBF.uvproj, settings and files
target EMBF (ARM-ADS)
  device: STM32F417ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: EMBF (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,RMII_MODE,P_A_000092
  c misc: --c99 --diag_suppress 236
  c include: ..\lwip-1.3.1\port;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip;..\src;..\session;..\STM32F4xx_StdPeriph_Driver\inc;..\os\inc;..\drivers\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: assage.c main.c startup_stm32f4xx.s stm32f4xx_it.c utils.c demo_test.c
  group lib
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4x7_eth.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group os
    ../os/src/: os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cpu_a.asm
  group drivers
    ../drivers/Drivers/: W25Qx.c adc.c ads1247.c canx.c dido.c drivers.c drv_power_meter.c EEPROM.c extwdg.c io_interface.c key.c LM240160.c netconf.c r8025.c rtc.c systick.c usartx.c ext_interrupt.c
  group lwip
    ../lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/port/: ethernetif.c
    ../lwip-1.3.1/src/netif/: etharp.c
  group inc
    ../src/: message.h
    ./: global.h
    ../drivers/PA000092/: drivers.h
  group session
    ../session/: task_net.c task_main.c
